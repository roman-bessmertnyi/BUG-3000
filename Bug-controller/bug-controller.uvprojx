# Keil uVision project bug-controller.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bug-controller
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\app;.\lib\State;.\lib\GPIO;.\lib\Keyboard;.\lib\tim_1637;.\lib\timer_lib;.\lib\USART_lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ./lib/State/: State.cpp State.h
    ./lib/Keyboard/: Keyboard.cpp Keyboard.h
    ./lib/tim_1637/: tm1637.cpp tm1637.h
    ./lib/USART_lib/: USART_lib.cpp USART_lib.h
    ./lib/timer_lib/: timer_lib.cpp timer_lib.h
  group app
    ./app/: main.cpp ControllerStates.cpp ControllerStates.h Services.cpp Services.h
software components: CMSIS:CORE 5.0.1, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
